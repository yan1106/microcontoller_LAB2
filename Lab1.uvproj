# Keil uVision project Lab1.uvproj, settings and files
target Target 1 (MCS-51)
  device: TM52F5288 tenx
  cpu: IRAM(0-0xFF) IROM(0x00-0x3FFF) CLOCK(12000000) XRAM(0xFF00-0xFFFF)
  output: Lab1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: seven.asm
    ../Lab2/: SEG_EQU.asm
